<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RF_TX.ewp</path>
  </project>
  <batchBuild />
</workspace>
